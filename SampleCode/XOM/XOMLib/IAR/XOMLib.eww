<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\XOMCode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\XOMLib.ewp</path>
  </project>
  <batchBuild/>
</workspace>



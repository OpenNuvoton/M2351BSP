# IAR project XOMLibDemo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2351 Nuvoton M2351
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2351\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\XOMLib\lib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: XOMLibDemo.bin
  ILINK.IlinkOutputFile: XOMLibDemo.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2351/Source/IAR/: startup_M2351.s
    ../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c dac.c retarget.c uart.c
    ../../XOMLib/lib/: xomlib.a
  group User
    ../: main.c

# Keil uVision project AES.uvprojx, settings and files
target AES (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: SHA256
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\mbedTLS\include\mbedtls;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: --map --first='startup_M2351.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../../Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
  group User
    ../: main.c aes_test.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c
  group mbedTLS
    ../../../../ThirdParty/mbedTLS/library/: aes.c bignum.c cipher.c cipher_wrap.c ctr_drbg.c debug.c dhm.c error.c md_wrap.c memory_buffer_alloc.c pk_wrap.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c timing.c version.c version_features.c xtea.c asn1parse.c asn1write.c base64.c ecp.c ecp_curves.c sha1.c sha256.c sha512.c rsa.c rsa_internal.c md.c pem.c md5.c oid.c pk.c ecdsa.c hmac_drbg.c

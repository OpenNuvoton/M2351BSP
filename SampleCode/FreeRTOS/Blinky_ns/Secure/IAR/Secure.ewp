# IAR project Secure.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2351 series Nuvoton M2351 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Nuvoton\M2351\Include; ..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: --cmse
  OBJCOPY.OOCOutputFile: Secure.bin
  postbuild: cmd.exe /c copy "Release\Exe\nsclib_Secure_IAR.o" "..\"
  ILINK.IlinkOutputFile: Secure.out
  ILINK.IlinkIcfFile: m2351_s.icf
  ILINK.IlinkExtraOptions: --import_cmse_lib_out=..\lib\nsclib_Secure_IAR.o
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2351/Source/IAR/: startup_M2351.s
    ../../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c retarget.c sys.c
  group User
    ../: main.c
    ../../: partition_M2351.h

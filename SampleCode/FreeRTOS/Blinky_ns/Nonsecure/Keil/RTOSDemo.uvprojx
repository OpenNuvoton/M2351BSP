# Keil uVision project RTOSDemo.uvprojx, settings and files
target M2351 (6190000::V6.19::ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: RTOSDemo
  c flags: v6Lang=5
  c define: DEBUG_PORT = UART1_NS, Heap_Size=0x3800
  c include: ..\..\..\Blinky_ns;..\..\Nonsecure;..\..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  group NSC
    ../../Secure/: nsclib.o
  group System
    ../../../../../Library/StdDriver/src/: retarget.c
    ../../: partition_M2351.h
    ../../../../../Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
    ../../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group FreeRTOS source
    ../../../../../ThirdParty/FreeRTOS/Source/: timers.c list.c queue.c tasks.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM0/: port.c
  group Demo App Source
    ../: main.c main-blinky.c FreeRTOSConfig.h main-full.c ParTest_M2351.c
    ./: RegTest_Keil.s
  group Common Demo Tasks
    ../../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: dynamic.c recmutex.c blocktim.c countsem.c QueueSet.c QueueOverwrite.c

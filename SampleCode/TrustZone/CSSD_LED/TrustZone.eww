<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$\Secure\IAR\Secure.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Nonsecure\IAR\Nonsecure.ewp</path>
    </project>

  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>Secure</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>Nonsecure</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



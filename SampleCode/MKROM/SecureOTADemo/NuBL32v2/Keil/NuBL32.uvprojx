# Keil uVision project NuBL32.uvprojx, settings and files
target NuBL32 (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: NuBL32_FW +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: FwSign.exe .\NuBL32_FW.bin\FLASH .\NuBL32_FW.bin\FWINFO 0x5E000
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c define: DEBUG_PORT=UART0_NS
  c include: ..\..\NuBL32v2;..\..\..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\common\inc;..\..\NuBL2\ota;..\..\..\..\..\ThirdParty\FatFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\NuBL32.sct
  link misc: --import-cmse-lib-out ..\lib\NuBL32_nsclib.o
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../: NuBL32_startup_M2351.s
  group User
    ../: NuBL32_main.c partition_M2351.h NuBL32_FwInfo.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c sys.c uart.c fmc.c sdh.c gpio.c clk.c MKROMLib_Keil.lib
    ../../NuBL2/lib/: NuBL2_nsclib.o

# Keil uVision project NonSecure.uvprojx, settings and files
target NonSecure (6120000::V6.12::.\ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: NonSecure +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c define: DEBUG_PORT = UART0_NS
  c include: ..\..\Secure;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\NonSecure.sct
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../../../Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
  group User
    ../: main_ns.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c MKROMLib_Keil.lib
    ../../Secure/lib/: nsclib_Secure.o

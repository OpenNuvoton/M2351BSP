   
LR_ROM 0x10040000 0x10000
{

    EXE_ROM +0
    {
        *.o(RESET, +First)
        *(+RO)
    }
    
    EXE_RAM 0x30010000 0x8000
    {
        *(+RW, +ZI)
    }
	
}

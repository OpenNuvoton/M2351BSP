# IAR project emWin_SimpleDemo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2351 series Nuvoton M2351 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: __DEMO_320x240__
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2351\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\emWin\Config; ..\..\..\..\ThirdParty\emWin\Include; ..\..\..\..\Library\NuMaker\emWin\lcm; ..\..\..\..\Library\NuMaker\emWin\tslib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: emWin_SimpleDemo.bin
  ILINK.IlinkOutputFile: emWin_SimpleDemo.out
  ILINK.IlinkIcfFile: m2351.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application
    ../Application/: FramewinDLG.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2351/Source/IAR/: startup_M2351.s
    ../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group emWin
    ../../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h
    ../../../../ThirdParty/emWin/Lib/: NUemWin_CM23_IAR.a
  group lcm
    ../../../../Library/NuMaker/emWin/lcm/: ILI9341.c lcm.h ST7735.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c eadc.c fmc.c gpio.c pdma.c retarget.c spi.c sys.c timer.c uart.c
  group tslib
    ../../../../Library/NuMaker/emWin/tslib/: fbutils.c M2351_320x240.c M2351TouchPanel.c testutils.c ts_calibrate.c
  group User
    ../: main.c

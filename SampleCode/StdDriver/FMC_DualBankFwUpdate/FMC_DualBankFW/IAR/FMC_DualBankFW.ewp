# IAR project FMC_DualBankFW.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2351 series Nuvoton M2351 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\; ..\..\common\inc; ..\..\..\..\..\Library\StdDriver\inc; ..\..\..\..\..\Library\Device\Nuvoton\M2351\Include; ..\..\..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_DualBankFW.bin
  ILINK.IlinkOutputFile: FMC_DualBankFW.out
  ILINK.IlinkIcfFile: m2351.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2351/Source/IAR/: startup_M2351.s
    ../../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c retarget.c uart.c
    ../: DrvUART.c
    ../../common/src/: NuDB_common.c
  group User
    ../: main.c

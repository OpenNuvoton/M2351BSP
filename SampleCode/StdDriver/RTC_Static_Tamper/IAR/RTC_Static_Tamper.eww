<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RTC_Static_Tamper.ewp</path>
  </project>
  <batchBuild/>
</workspace>



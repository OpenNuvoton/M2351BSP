# IAR project I2S_Codec_PDMA.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2351 series Nuvoton M2351 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2351\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2S_Codec_PDMA.bin
  ILINK.IlinkOutputFile: I2S_Codec_PDMA.out
  ILINK.IlinkIcfFile: m2351.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2351/Source/IAR/: startup_M2351.s
    ../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c i2s.c pdma.c retarget.c sys.c uart.c
  group User
    ../: main.c

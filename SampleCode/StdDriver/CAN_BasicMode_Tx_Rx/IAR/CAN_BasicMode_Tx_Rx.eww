<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CAN_BasicMode_Tx_Rx.ewp</path>
  </project>
  <batchBuild/>
</workspace>



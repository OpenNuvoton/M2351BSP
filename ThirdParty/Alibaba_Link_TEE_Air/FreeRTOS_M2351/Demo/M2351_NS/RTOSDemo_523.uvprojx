# Keil uVision project RTOSDemo_523.uvprojx, settings and files
target M2351 (6100001::V6.10.1::.\ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.0
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: RTOSDemo +hex
  c flags: v6Lang=5 wLevel=1
  c define: DEBUG_PORT = UART0_NS,CONFIG_DBG
  c include: ..\..\Source\include;..\Common\include;.\Library\CMSIS\Include;.\Keil_Specific;.\Library\Device\Nuvoton\M2351\Include;.\Library\StdDriver\inc;..\..\Source\portable\RVDS\ARM_V8M;..\M2351_NS;..\..\Link_TEE_Air_v2.0.0\src\ntw\inc;..\..\Link_TEE_Air_v2.0.0\samples\xor\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  group NSC
    ../../Link_TEE_Air_v2.0.0/src/ntw/nsc/: nsc-implib.lib
  group System
    ./Library/StdDriver/src/: retarget.c clk.c
    ./: partition_M2351.h
    ./Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
    ./Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group FreeRTOS source
    ../../Source/: timers.c list.c queue.c tasks.c osa.c
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/RVDS/ARM_V8M/: port.c
  group Demo App Source
    ./: main.c main-blinky.c FreeRTOSConfig.h main-full.c ParTest_M2351.c RegTest_Keil.s
  group Common Demo Tasks
    ../Common/Minimal/: dynamic.c recmutex.c blocktim.c countsem.c QueueSet.c QueueOverwrite.c
  group tzdd
    ../../Link_TEE_Air_v2.0.0/src/ntw/drv/: drv.a
  group tzdd_inc
    ../../Link_TEE_Air_v2.0.0/src/ntw/inc/: tee_client_api.h teec_lpm_api.h tee_types.h tee_print.h
  group lpm
    ../../Link_TEE_Air_v2.0.0/src/ntw/lpm/: lpm.a
  group test_cas
    ../../Link_TEE_Air_v2.0.0/samples/xor/ntw/: xor_ca.c
  group test_cas_inc
    ../../Link_TEE_Air_v2.0.0/samples/xor/inc/: xor.h
target M2351_UlinkPro (6100001::V6.10.1::.\ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.0
  cpu: as above
  output: RTOSDemo
  c flags: v6Lang=5 wLevel=1
  c define: DEBUG_PORT = UART0_NS,CONFIG_DBG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
target M2351_Ulink2 (6100001::V6.10.1::.\ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.0
  cpu: as above
  output: RTOSDemo
  c flags: v6Lang=5 wLevel=1
  c define: DEBUG_PORT = UART0_NS,CONFIG_DBG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
